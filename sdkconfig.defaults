## sdkconfig.defaults
```kconfig
# Default sdkconfig settings
CONFIG_ESP_CONSOLE_UART_DEFAULT=y
CONFIG_FREERTOS_UNICORE=y
CONFIG_ESP_WIFI_ENABLED=y
CONFIG_I2S_ENABLED=y
```
